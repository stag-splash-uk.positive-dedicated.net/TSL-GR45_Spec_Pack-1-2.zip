Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2018-03-01T00:43:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160314_0715(x64) - Exporter 16.0.1124.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 01 00:43:52 2018 * Host: DESKTOP-HSFH8JC * Database: C:\Users\C559~1\AppData\Local\Temp\{0AC4C18E-3117-43F4-9D69-8161C9D7D37B}\ifc * Database version: 5507 * Database creation date: Thu Mar 01 00:43:52 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 01 00:43:52 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 01 00:43:52 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: TSL-GR45RH_Satin, Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB:TSL-GR45RH_Satin:321834
In: Level 1
Type - Classification: C1030200 Bath & Toilet Accessories (Uniformat); Material: Steel-Splashlab-Satin
Type - Constraints - Default Elevation: 900 mm
Type - Identity Data - _distributed by: www.thesplashlab.com; Assembly Code: C1030200; Assembly Description: Bath & Toilet Accessories; Description: The TSL-GR45RH is a hinged single arm support bar. This grab bar has a locking mechanism which holds the bar in a vertical or horizontal position, and comes with concealed fixings and flush plate.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: N13/340; Manufacturer: The Splash Lab; Model: TSL-GR45RH; OmniClass Number: 23.40.20.21.47; OmniClass Title: Bath Grab Bars; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Satin finish; Type Name: TSL-GR45RH_Satin; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Steel-Splashlab-Satin
Type - Other - Category: Specialty Equipment; _BIMspec_GUID: 0; _current revision: 1; Family Name: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0
Type - Text - _created by: www.thesplashlab.com; AssetType: fixed; CreatedBy: www.thesplashlab.com; CreatedOn: Jul-2017; DurationUnit: Years; ExpectedLife: 2; Finish: Satin; Grade: 304; Manufacturer Tel: 0161 482 7000; Material: Stainless Steel; Mtrl_Finish: Satin; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; NBSObjectName: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB; NBSReference: 45-35-72/368; TypeName: TSL-GR45RH; Uniclass2: 45-35-72/368; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 24; WarrantyDurationUnit: months; WarrantyStartDate: (default)
Pset_BuildingElementProxyCommon - Reference: TSL-GR45RH_Satin
Pset_ManufacturerTypeInformation - Manufacturer: The Splash Lab
Constraints - Elevation: 0 mm; Host: Level : Level 1; Left_Version: yes; Level: Level: Level 1; Up: yes
Dimensions - Area: 0.0984708 m2; Bar Angle: 90 deg; Offset: -122 mm; Volume: 0.00136828 m3
Other - Family: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB: TSL-GR45RH_Satin; Family and Type: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB: TSL-GR45RH_Satin; Schedule Level: Level: Level 1; Type: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB: TSL-GR45RH_Satin; Type Id: Grab_Bar-TSL-GR45RH-Arm_Support-THESPLASHLAB: TSL-GR45RH_Satin
Phasing - Phase Created: New Construction
